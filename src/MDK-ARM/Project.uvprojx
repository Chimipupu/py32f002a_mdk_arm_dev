# Keil uVision project Project.uvprojx, settings and files
target PY32F002Ax5_Project (6240000::V6.24::ARMCLANG)
  device: PY32F030x6 Puya
  pack: Puya.PY32F0xx_DFP.1.2.8
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00008000) IROM2(0x1FFF0E80,0x00000010) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: py32f002a_dev +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,PY32F030x6
  c include: ..\Inc;..\..\..\Drivers\CMSIS\Include;..\..\..\Drivers\CMSIS\Device\PY32F0xx\Include;..\..\..\Drivers\PY32F0xx_HAL_Driver\Inc;.\Inc;.\Driver\Inc;.\APP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT5: ROM 0x1fff0e80 size 0x10
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Driver/Inc
    ./Driver/Inc/: py32f0xx_ll_adc.h py32f0xx_ll_bus.h py32f0xx_ll_comp.h py32f0xx_ll_cortex.h py32f0xx_ll_crc.h py32f0xx_ll_dma.h py32f0xx_ll_exti.h py32f0xx_ll_flash.h py32f0xx_ll_gpio.h py32f0xx_ll_i2c.h py32f0xx_ll_iwdg.h py32f0xx_ll_led.h py32f0xx_ll_lptim.h py32f0xx_ll_pwr.h py32f0xx_ll_rcc.h py32f0xx_ll_rtc.h py32f0xx_ll_spi.h py32f0xx_ll_system.h py32f0xx_ll_tim.h py32f0xx_ll_usart.h py32f0xx_ll_utils.h py32f0xx_ll_wwdg.h py32f0xx.h py32f002ax5.h
  group Driver/Src
    ./Driver/Src/: py32f0xx_ll_adc.c py32f0xx_ll_comp.c py32f0xx_ll_crc.c py32f0xx_ll_dma.c py32f0xx_ll_exti.c py32f0xx_ll_gpio.c py32f0xx_ll_i2c.c py32f0xx_ll_led.c py32f0xx_ll_lptim.c py32f0xx_ll_pwr.c py32f0xx_ll_rcc.c py32f0xx_ll_rtc.c py32f0xx_ll_spi.c py32f0xx_ll_tim.c py32f0xx_ll_usart.c py32f0xx_ll_utils.c
  group Startup
    ./: startup_py32f002xx.s
  group App
    ./APP/: main.c app_main.c state_machine.c i2c_s_reg.c py32f0xx_it.c system_py32f0xx.c
  group CMSIS
    ./CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armcc_V6.h cmsis_gcc.h core_cm0plus.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
software components: CMSIS:CORE 6.1.1
